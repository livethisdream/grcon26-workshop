options:
  parameters:
    author: GRCon26 workshop
    comment: |-
      Three jumpers: DIO0-DIO4, DIO1-DIO5, DIO2-DIO6.

      SPI mode 0, bit-banged one bit per sample. Change spi_message and
      watch the MOSI trace change; the same bytes come back out of the
      decoder, which reads MOSI at each rising SCLK edge while CS is low.

      The buffer must be cyclic. Non-cyclic streaming underruns about half
      the time at 1 MS/s and drops samples in the middle of a frame.
    description: Bit-banged SPI mode 0 out of DIO0-2, back in on DIO4-6, decoded to bytes.
    generate_options: qt_gui
    id: m2k_spi_loopback_continuous
    output_language: python
    title: M2K SPI loopback - continuous, three DIO pins
  states: {}

blocks:
- name: buffer_len
  id: variable
  parameters:
    comment: Whole frames, and a frame is a whole message. Both blocks use it.
    value: frame * repeats
  states: {}
- name: frame
  id: variable
  parameters:
    comment: One frame is one whole transaction. Fixed by spi_capacity, not by the message, because the sink's buffer size cannot change while it runs.
    value: 128 + 16 * half * spi_capacity
  states: {}
- name: half
  id: variable
  parameters:
    comment: Samples per half clock. 8 at 1 MS/s is a 62.5 kHz SCLK.
    value: '8'
  states: {}
- name: repeats
  id: variable
  parameters:
    comment: As many whole messages as fit a 16384-sample buffer.
    value: max(1, 16384 // frame)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: spi_bits
  id: variable
  parameters:
    comment: MSB first, the way SPI sends it.
    value: |-
      [[(byte >> (7 - i)) & 1 for i in range(8)]
       for byte in spi_bytes]
  states: {}
- name: spi_bytes
  id: variable
  parameters:
    comment: The message, cut to what the frame holds.
    value: '[ord(ch) for ch in str(spi_message)[:spi_capacity]]'
  states: {}
- name: spi_capacity
  id: variable
  parameters:
    comment: Longest message the frame has room for. Raise it and restart to send more; the frame grows with it whether or not you use the space.
    value: '8'
  states: {}
- name: spi_cs
  id: variable
  parameters:
    comment: Asserted low once, across the whole message -- the only falling edge in the frame is the start of the message, which is what the capture triggers on.
    value: ([1] * 64 + [0] * (16 + 16 * half * len(spi_bytes)) + [1] * (48 + spi_pad))
  states: {}
- name: spi_message
  id: variable_qtgui_entry
  parameters:
    comment: Type here while it runs. Anything past spi_capacity is cut.
    entry_signal: returnPressed
    label: SPI message
    type: string
    value: M2K
  states: {}
- name: spi_mosi
  id: variable
  parameters:
    comment: Each bit is presented while SCLK is low, so it is already settled at the rising edge.
    value: ([0] * 64 + [spi_bits[0][0] if spi_bits else 0] * 8 + [b for bits in spi_bits for bit in bits for b in [bit] * (2 * half)] + [0] * (56 + spi_pad))
  states: {}
- name: spi_pad
  id: variable
  parameters:
    comment: Idle samples that keep a short message the same length as a full one. CS is already high here, so the decoder ignores all of it.
    value: 16 * half * (spi_capacity - len(spi_bytes))
  states: {}
- name: spi_sclk
  id: variable
  parameters:
    comment: Idle low, eight pulses per byte with no gap between them, idle low.
    value: ([0] * 72 + ([0] * half + [1] * half) * (8 * len(spi_bytes)) + [0] * (56 + spi_pad))
  states: {}
- name: cs_f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: cs_src
  id: blocks_vector_source_x
  parameters:
    comment: CS -> DIO2
    repeat: 'True'
    type: short
    vector: spi_cs
  states: {}
- name: m2k_digital_sink_0
  id: m2k_digital_sink
  parameters:
    buffer_size: buffer_len
    comment: |-
      Whole messages per buffer, pushed once and
      repeated by the hardware.
    cyclic: 'True'
    drive: '''push-pull'''
    idle_level: '''low'''
    name0: SCLK
    name1: MOSI
    name10: ''
    name11: ''
    name12: ''
    name13: ''
    name14: ''
    name15: ''
    name2: CS
    name3: ''
    name4: ''
    name5: ''
    name6: ''
    name7: ''
    name8: ''
    name9: ''
    num_lines: '3'
    pin0: '0'
    pin1: '1'
    pin10: '10'
    pin11: '11'
    pin12: '12'
    pin13: '13'
    pin14: '14'
    pin15: '15'
    pin2: '2'
    pin3: '3'
    pin4: '4'
    pin5: '5'
    pin6: '6'
    pin7: '7'
    pin8: '8'
    pin9: '9'
    sample_rate: '1000000'
    uri: ip:192.168.2.1
  states: {}
- name: m2k_digital_source_0
  id: m2k_digital_source
  parameters:
    buffer_size: buffer_len
    comment: |-
      Triggered on CS falling, so every capture
      starts at the head of a frame.
    name0: SCLK
    name1: MOSI
    name10: ''
    name11: ''
    name12: ''
    name13: ''
    name14: ''
    name15: ''
    name2: CS
    name3: ''
    name4: ''
    name5: ''
    name6: ''
    name7: ''
    name8: ''
    name9: ''
    num_lines: '3'
    pin0: '4'
    pin1: '5'
    pin10: '10'
    pin11: '11'
    pin12: '12'
    pin13: '13'
    pin14: '14'
    pin15: '15'
    pin2: '6'
    pin3: '3'
    pin4: '4'
    pin5: '5'
    pin6: '6'
    pin7: '7'
    pin8: '8'
    pin9: '9'
    sample_rate: '1000000'
    trigger_condition: '''edge-falling'''
    trigger_delay: '0'
    trigger_pin: '6'
    uri: ip:192.168.2.1
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Prints the bytes as they arrive.
  states: {}
- name: mosi_f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: mosi_src
  id: blocks_vector_source_x
  parameters:
    comment: MOSI -> DIO1
    repeat: 'True'
    type: short
    vector: spi_mosi
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Two frames wide, whatever `half` is set to.
    grid: 'True'
    label1: SCLK
    label2: MOSI
    label3: CS
    name: '"SPI mode 0 - captured on DIO4-6"'
    nconnections: '3'
    size: 2 * frame
    srate: samp_rate
    type: float
    ylabel: Volts
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: sclk_f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: sclk_src
  id: blocks_vector_source_x
  parameters:
    comment: SCLK -> DIO0
    repeat: 'True'
    type: short
    vector: spi_sclk
  states: {}
- name: spi_decode_0
  id: m2k_spi_decode
  parameters:
    bits_per_word: '8'
    comment: |-
      The three streams back into bytes.
      Nothing here touches the board.
    cs_active_low: 'True'
  states: {}

connections:
- [cs_f, '0', qtgui_time_sink_x_0, '2']
- [cs_src, '0', m2k_digital_sink_0, '2']
- [m2k_digital_source_0, '0', sclk_f, '0']
- [m2k_digital_source_0, '0', spi_decode_0, '0']
- [m2k_digital_source_0, '1', mosi_f, '0']
- [m2k_digital_source_0, '1', spi_decode_0, '1']
- [m2k_digital_source_0, '2', cs_f, '0']
- [m2k_digital_source_0, '2', spi_decode_0, '2']
- [mosi_f, '0', qtgui_time_sink_x_0, '1']
- [mosi_src, '0', m2k_digital_sink_0, '1']
- [sclk_f, '0', qtgui_time_sink_x_0, '0']
- [sclk_src, '0', m2k_digital_sink_0, '0']
- [spi_decode_0, bytes, message_debug_0, print_pdu]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
